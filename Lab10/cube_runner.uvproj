# Keil uVision project cube_runner.uvproj, settings and files
target Game (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Game
  c flags: Optim=2
  c misc: -c99
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s PLL.c ADC.c cube_runner.c game.c graphics.c interrupts.c LCD.c SSD2118.c game.h graphics.h graphics_tm4c123.h interrupts.h LCD.h PLL.h tm4c123gh6pm.h
